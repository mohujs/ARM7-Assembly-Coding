;ASM code to find 0S AND 1S and total count IN EACH BYTE
 	AREA Program, CODE, READONLY
    ENTRY
MAIN	LDR	R0,VALUE1 
		AND	R1,R0,#0XFF	   ;MASK LSB 1ST BYTE
		MOV R10,#0X8
LABEL1 	MOVS R1,R1,LSR#1
		ADDCS R2,R2,#1			;NO. OF ONES	=0xd=13
		ADDCC R3,R3,#1		   	;NO. OF ZEROS	=0x13=19
		SUB R10,R10,#1
		CMP  R10,#0X00
		BNE LABEL1
					
		AND	R1,R0,#0XFF00  ;MASK LSB 2ND BYTE
		LSR R1,R1,#8
		MOV R10,#0X8
LABEL2 	MOVS R1,R1,LSR#1
		ADDCS R4,R4,#1			;NO. OF ONES	=0xd=13
		ADDCC R5,R5,#1		   	;NO. OF ZEROS	=0x13
		SUB R10,R10,#1
		CMP  R10,#0X00
		BNE LABEL2

		
		AND	R1,R0,#0XFF0000;MASK LSB 3RD BYTE
		LSR R1,R1,#16
		MOV R10,#0X8
LABEL3 	MOVS R1,R1,LSR#1
		ADDCS R6,R6,#1			;NO. OF ONES	=0xd=13
		ADDCC R7,R7,#1		   	;NO. OF ZEROS	=0x13=19
		SUB R10,R10,#1
		CMP  R10,#0X00
		BNE LABEL3

		AND	R1,R0,#0XFF000000;MASK LSB 3RD BYTE
		LSR R1,R1,#24
		MOV R10,#0X8
LABEL4 	MOVS R1,R1,LSR#1
		ADDCS R8,R8,#1			;NO. OF ONES	=0xd=13
		ADDCC R9,R9,#1		   	;NO. OF ZEROS	=0x13=19
		SUB R10,R10,#1
		CMP  R10,#0X00
		BNE LABEL4

		ADD R11,R2,R3
		ADD R11,R11,R4
		ADD R11,R11,R5
		ADD R11,R11,R6
		ADD R11,R11,R7
		ADD R11,R11,R8
		ADD R11,R11,R9
		STR R1,RESULT
		SWI &11

VALUE1	DCD	&12345678
RESULT	DCD 0
		END